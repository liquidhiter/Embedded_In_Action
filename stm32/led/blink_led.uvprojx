# Keil uVision project blink_led.uvprojx, settings and files
target led (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: blink_led
  AfterMake: fromelf  --bin  --output=blink_led.bin  Objects\blink_led.axf
  AfterMake: fromelf  --text  -a -c  --output=blink_led.dis  Objects\blink_led.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./: main.c
  group start
    ./: start.s
