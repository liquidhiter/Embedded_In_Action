# Keil uVision project uart.uvprojx, settings and files
target uart (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uart
  AfterMake: fromelf  --bin  --output=uart_relocate.bin  Objects\uart.axf
  AfterMake: fromelf  --text  -a -c  --output=uart_relocate.dis  Objects\uart.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=4
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./: main.c
  group start
    ./: start.s
  group uart_driver
    ./: uart.h uart.c
  group utils
    ./: util.c util.h mystring.h mystring.c led.c led.h peipheral_reg_def.h
  group exception
    ./: exception.c exception.h
  group systick
    ./: systick.h systick.c
  group key
    ./: key.c key.h
  group exti
    ./: exti.c exti.h
  group nvic
    ./: nvic.h nvic.c
